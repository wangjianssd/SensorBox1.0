# IAR project detector.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430F5359 MSP430F5359
  General.GStackSize2: 1024
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: SILABS_RADIO_SI446X
  ICC430.newCCIncludePaths: ..\..\..\apps\detector\node_cfg; ..\..\..\apps\; ..\..\..\common\dev\; ..\..\..\common\dev\si4463\; ..\..\..\common\dev\m24lr04e\; ..\..\..\include\; ..\..\..\include\common\lib\; ..\..\..\include\common\hal\; ..\..\..\include\common\dev\; ..\..\..\include\platform\; ..\..\..\include\sys_arch\; ..\..\..\include\stack\; ..\..\..\include\stack\common\; ..\..\..\include\stack\stack_module\; ..\..\..\include\stack\stack_module\mac_module\; ..\..\..\platform\core430\include\; ..\..\..\platform\core430\include\driver\; ..\..\..\platform\core430\osel\wsnos\detector\; ..\..\..\sys_arch\wsnos\; ..\..\..\stack\custom\nwk\; ..\..\..\stack\custom\phy\; ..\..\..\stack\custom\mac\; ..\..\..\stack\custom\mac\general\; ..\..\..\stack\custom\mac\core\sync\; ..\..\..\stack\custom\mac\core\asyn\
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: USE_LARGE_CODE_MODEL=1
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F5359.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  ICC430.CCDefines: NDEBUG
  ICC430.newCCIncludePaths: ..\..\apps\dc4\detector\node_cfg\; ..\..\include\; ..\..\include\common\lib\; ..\..\include\common\hal\; ..\..\include\platform\; ..\..\include\sys_arch\; ..\..\include\stack\; ..\..\include\stack\common\; ..\..\include\stack\stack_module\; ..\..\include\stack\stack_module\mac_module\; ..\..\platform\5438A_SI4432_WSNOS\include\; ..\..\platform\5438A_SI4432_WSNOS\include\driver\; ..\..\platform\5438A_SI4432_WSNOS\osel\wsnos\detector\; ..\..\sys_arch\wsnos\; ..\..\stack\custom\tag\include\; ..\..\stack\custom\tag\include\app; ..\..\stack\custom\tag\include\mac; ..\..\stack\custom\tag\include\phy; ..\..\stack\custom\tag\include\nwk; ..\..\apps\dc4\node_cfg\detector\; ..\..\apps\dc4\detector\node_cfg\; ..\..\apps\dc4\detector\include\
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: lnk430f5438.xcl
  group apps
    ../../../apps/: app.c app.h
    ../../../apps/detector/node_cfg/: node_cfg.h
  group common/dev/m24lr04e
    ../../../common/dev/m24lr04e/: m24lr04e.c
  group common/dev/m24lr04e/inc
    ../../../common/dev/m24lr04e/inc/: m24lr04e.h
  group common/dev/si446x
    ../../../common/dev/si4463/: radio.c radio_comm.c si446x_api_lib.c
  group common/dev/si446x/inc
    ../../../common/dev/si4463/inc/: compiler_defs.h radio.h radio_comm.h radio_config.h si446x_api_lib.h si446x_cmd.h si446x_defs.h si446x_patch.h si446x_prop.h
  group common/hal
    ../../../common/hal/: hal_board.c hal_clock.c hal_energy.c hal_gpio.c hal_nvmem.c hal_sensor.c hal_timer.c hal_uart.c
  group common/lib
    ../../../common/lib/: bootloader.c crc.c debug.c list.c portablelonglong.c printf.c serial.c sqqueue.c srandom.c
  group include/common/dev
    ../../../include/common/dev/: dev.h nfc_defs.h radio_defs.h
  group include/common/hal
    ../../../include/common/hal/: hal.h hal_board.h hal_clock.h hal_energy.h hal_gpio.h hal_low_power.h hal_nvmem.h hal_sensor.h hal_timer.h hal_uart.h
  group include/common/lib
    ../../../include/common/lib/: bootloader.h crc.h data_type_def.h debug.h lib.h list.h portablelonglong.h printf.h serial.h sqqueue.h srandom.h
  group include/platform
    ../../../include/platform/: platform.h
  group include/stack
    ../../../include/stack/: stack.h
  group include/stack/module
    ../../../include/stack/stack_module/mac_module/: m_main_ctrl.h m_slot.h m_sync.h m_tran.h mac_module.h
  group include/stack/stack_lib
    ../../../include/stack/common/: pbuf.h prim.h sbuf.h
  group include/sys_arch
    ../../../include/sys_arch/: osel_arch.h
  group paltform/core430/driver
    ../../../platform/core430/driver/: board.c clock.c energy.c flash.c gpio.c i2c.c m24lr64e_arch.c pmap.c si4463_arch.c timer.c uart.c
  group paltform/core430/include/driver
    ../../../platform/core430/include/driver/: board.h clock.h driver.h energy.h flash.h gpio.h pmap.h rtc.h sensor.h si4463_arch.h socket.h timer.h uart.h
  group paltform/core430/main
    ../../../platform/core430/init/: cstartup.s43 main.c
  group paltform/core430/os/ports
    ../../../platform/core430/osel/wsnos/detector/: wsnos_config.h wsnos_port.c wsnos_port.h
  group stack
    ../../../stack/: stack.c
  group stack/custom/mac
    ../../../stack/custom/mac/: mac.c mac.h
  group stack/custom/mac/core/asyn
    ../../../stack/custom/mac/core/asyn/: asyn_ctrl.c asyn_ctrl.h asyn_define.h asyn_frame.c asyn_frame.h asyn_gateway.c asyn_gateway.h asyn_general.c asyn_general.h asyn_router.c asyn_router.h asyn_terminal.c asyn_terminal.h
  group stack/custom/mac/core/sync
    ../../../stack/custom/mac/core/sync/: sync_ctrl.c sync_ctrl.h sync_define.h sync_gateway.c sync_gateway.h sync_general.c sync_general.h sync_mac_package.c sync_mac_package.h sync_router.c sync_router.h sync_terminal.c sync_terminal.h
  group stack/custom/mac/general
    ../../../stack/custom/mac/general/: assos_table.c assos_table.h general.c general.h mac_frame.c mac_frame.h mac_package.c mac_package.h neighbors.c neighbors.h
  group stack/custom/nwk
    ../../../stack/custom/nwk/: nwk_frames.c nwk_frames.h nwk_handles.h nwk_interface.h nwk_route.c nwk_route.h terminal_nwk.c
  group stack/custom/phy
    ../../../stack/custom/phy/: phy_cca.c phy_cca.h phy_packet.c phy_packet.h phy_state.c phy_state.h
  group stack/module
    ../../../stack/module/mac_module/: m_slot.c m_sync.c m_tran.c
  group stack/stack_lib
    ../../../stack/common/: pbuf.c sbuf.c
  group sys_arch
    ../../../sys_arch/: osel_arch.c
  group sys_arch/wsnos
    ../../../sys_arch/wsnos/: wsnos_equeue.c wsnos_etimer.c wsnos_init.c wsnos_mem.c wsnos_pthread.c wsnos_sched.c wsnos_task.c
  group sys_arch/wsnos/inc
    ../../../sys_arch/wsnos/: wsnos.h wsnos_default.h wsnos_equeue.h wsnos_etimer.h wsnos_mem.h wsnos_pthread.h wsnos_sched.h wsnos_task.h
