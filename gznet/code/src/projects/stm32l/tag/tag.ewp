# IAR project tag.ewp, settings and files
configuration core_stm32l (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151xD ST STM32L151xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SILABS_RADIO_SI446X; PF_CORE_M3; STM32L151xD; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\; ..\..\..\apps\tag\node_cfg\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: tag.out
  ILINK.IlinkIcfFile: ..\..\..\platform\core_stm32l\init\stm32l151xD.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../: gznet.h
  group apps
    ../../../apps/tag/node_cfg/: node_cfg.h wsnos_config.h
  group apps/demo
    ../../../apps/tag/demo/: app.c app.h
  group common/dev
    ../../../common/dev/: dev.h radio_defs.h
  group common/dev/si4463
    ../../../common/dev/si4463/: radio.c radio_comm.c si446x_api_lib.c
  group common/dev/si4463/inc
    ../../../common/dev/si4463/: compiler_defs.h radio.h radio_comm.h radio_config.h si446x_api_lib.h si446x_cmd.h si446x_defs.h si446x_patch.h si446x_prop.h
  group common/hal
    ../../../common/hal/: hal_board.c hal_clock.c hal_energy.c hal_gpio.c hal_nvmem.c hal_uart.c
  group common/hal/inc
    ../../../common/hal/: hal.h hal_board.h hal_clock.h hal_energy.h hal_gpio.h hal_low_power.h hal_nvmem.h hal_uart.h
  group common/lib
    ../../../common/lib/: bootloader.c crc.c debug.c list.c portablelonglong.c printf.c serial.c sqqueue.c srandom.c
  group common/lib/inc
    ../../../common/lib/: bootloader.h crc.h data_type_def.h debug.h lib.h list.h portablelonglong.h printf.h serial.h sqqueue.h srandom.h
  group platform
    ../../../platform/: platform.h platform_def.h
  group platform/core_stm32l/drivers
    ../../../platform/core_stm32l/drivers/: board.c clock.c flash.c gpio.c rtimer_arch.c si4463_arch.c stm32l1xx_it.c uart.c wdt.c
  group platform/core_stm32l/drivers/inc
    ../../../platform/core_stm32l/drivers/: board.h clock.h driver.h flash.h gpio.h rtimer_arch.h si4463_arch.h stm32l1xx_it.h uart.h wdt.h
  group platform/core_stm32l/init
    ../../../platform/core_stm32l/init/: main.c startup_stm32l151xd.s
  group platform/core_stm32l/libs/cmsis
    ../../../platform/core_stm32l/libs/cmsis/: stm32l151xd.h stm32l1xx.h stm32l1xx_hal_conf.h system_stm32l1xx.c system_stm32l1xx.h
  group platform/core_stm32l/libs/stm32l1xx_hal
    ../../../platform/core_stm32l/libs/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_msp_template.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_sdmmc.c
  group platform/core_stm32l/libs/stm32l1xx_hal/inc
    ../../../platform/core_stm32l/libs/STM32L1xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../../../platform/core_stm32l/libs/STM32L1xx_HAL_Driver/Inc/: stm32l1xx_hal.h stm32l1xx_hal_adc.h stm32l1xx_hal_adc_ex.h stm32l1xx_hal_comp.h stm32l1xx_hal_comp_ex.h stm32l1xx_hal_conf_template.h stm32l1xx_hal_cortex.h stm32l1xx_hal_crc.h stm32l1xx_hal_cryp.h stm32l1xx_hal_cryp_ex.h stm32l1xx_hal_dac.h stm32l1xx_hal_dac_ex.h stm32l1xx_hal_def.h stm32l1xx_hal_dma.h stm32l1xx_hal_dma_ex.h stm32l1xx_hal_flash.h stm32l1xx_hal_flash_ex.h stm32l1xx_hal_flash_ramfunc.h stm32l1xx_hal_gpio.h stm32l1xx_hal_gpio_ex.h stm32l1xx_hal_i2c.h stm32l1xx_hal_i2s.h stm32l1xx_hal_irda.h stm32l1xx_hal_iwdg.h stm32l1xx_hal_lcd.h stm32l1xx_hal_nor.h stm32l1xx_hal_opamp.h stm32l1xx_hal_opamp_ex.h stm32l1xx_hal_pcd.h stm32l1xx_hal_pcd_ex.h stm32l1xx_hal_pwr.h stm32l1xx_hal_pwr_ex.h stm32l1xx_hal_rcc.h stm32l1xx_hal_rcc_ex.h stm32l1xx_hal_rtc.h stm32l1xx_hal_rtc_ex.h stm32l1xx_hal_sd.h stm32l1xx_hal_smartcard.h stm32l1xx_hal_spi.h stm32l1xx_hal_spi_ex.h stm32l1xx_hal_sram.h stm32l1xx_hal_tim.h stm32l1xx_hal_tim_ex.h stm32l1xx_hal_uart.h stm32l1xx_hal_usart.h stm32l1xx_hal_wwdg.h stm32l1xx_ll_fsmc.h stm32l1xx_ll_sdmmc.h
  group stack
    ../../../stack/: stack.c stack.h
  group stack/custom/mac
    ../../../stack/custom/mac/: mac.c mac.h
  group stack/custom/mac/core/asyn
    ../../../stack/custom/mac/core/asyn/: asyn_ctrl.c asyn_ctrl.h asyn_define.h asyn_frame.c asyn_frame.h asyn_gateway.c asyn_gateway.h asyn_general.c asyn_general.h asyn_router.c asyn_router.h asyn_terminal.c asyn_terminal.h
  group stack/custom/mac/core/sync
    ../../../stack/custom/mac/core/sync/: sync_ctrl.c sync_ctrl.h sync_define.h sync_gateway.c sync_gateway.h sync_general.c sync_general.h sync_mac_package.c sync_mac_package.h sync_router.c sync_router.h sync_terminal.c sync_terminal.h
  group stack/custom/mac/general
    ../../../stack/custom/mac/general/: assos_table.c assos_table.h general.c general.h mac_frame.c mac_frame.h mac_package.c mac_package.h neighbors.c neighbors.h
  group stack/custom/nwk
    ../../../stack/custom/nwk/: nwk_frames.c nwk_frames.h nwk_handles.c nwk_handles.h nwk_interface.h nwk_route.c nwk_route.h
  group stack/custom/phy
    ../../../stack/custom/phy/: phy_cca.c phy_cca.h phy_packet.c phy_packet.h phy_state.c phy_state.h
  group stack/module/mac_module
    ../../../stack/module/mac_module/: hal_timer.c hal_timer.h m_slot.c m_slot.h m_sync.c m_sync.h m_tran.c m_tran.h mac_module.h
  group stack/stack_lib
    ../../../stack/common/: pbuf.c pbuf.h prim.h sbuf.c sbuf.h
  group sys_arch
    ../../../sys_arch/: osel_arch.c osel_arch.h
  group sys_arch/ports
    ../../../sys_arch/ports/stm32l/: cpu_port.c wsnos_port.h wsnos_port.s
  group sys_arch/wsnos
    ../../../sys_arch/wsnos/: wsnos_equeue.c wsnos_etimer.c wsnos_init.c wsnos_mem.c wsnos_pthread.c wsnos_sched.c wsnos_task.c
  group sys_arch/wsnos/inc
    ../../../sys_arch/wsnos/: wsnos.h wsnos_default.h wsnos_equeue.h wsnos_etimer.h wsnos_mem.h wsnos_pthread.h wsnos_sched.h wsnos_task.h
