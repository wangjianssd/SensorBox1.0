# IAR project tag_coap_cor430.ewp, settings and files
configuration demo_coap_client (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430F5359 MSP430F5359
  General.GStackSize2: 1024
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: SILABS_RADIO_SI446X; PF_CORE_430
  ICC430.newCCIncludePaths: ..\..\..\; ..\..\..\apps\tag_coap\node_cfg\; ..\..\..\apps\tag_coap\demo_coap_client\
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: USE_LARGE_CODE_MODEL=1
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F5359.xcl
  XLINK.XlinkStackSize: 1
configuration demo_coap_led (MSP430, debug)
  as the first configuration, except:
  ICC430.newCCIncludePaths: ..\..\..\; ..\..\..\apps\tag_coap\node_cfg\; ..\..\..\apps\tag_coap\demo_coap_led\
configuration demo_coap_server (MSP430, debug)
  as the first configuration, except:
  ICC430.newCCIncludePaths: ..\..\..\; ..\..\..\apps\tag_coap\node_cfg\; ..\..\..\apps\tag_coap\demo_coap_server\
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F5438.xcl
  group (top)
    ./: lnk430f5438.xcl
  group apps
    ../../../apps/tag_coap/node_cfg/: node_cfg.h wsnos_config.h
  group apps/demo_coap_client
    ../../../apps/tag_coap/demo_coap_client/: app.c app.h
  group apps/demo_coap_led
    ../../../apps/tag_coap/demo_coap_led/: app.c app.h
  group apps/demo_coap_server
    ../../../apps/tag_coap/demo_coap_server/: app.c app.h endpoints.c
  group common/at
    ../../../common/at/: at_common.c at_common.h at_mod.c at_mod.h
  group common/coap
    ../../../common/coap/: coap_client.c coap_client.h coap_server.c coap_server.h
  group common/dev
    ../../../common/dev/: dev.h radio_defs.h
  group common/dev/si4432
    ../../../common/dev/si4432/: radio.c radio.h
  group common/dev/si4463
    ../../../common/dev/si4463/: compiler_defs.h radio.c radio.h radio_comm.c radio_comm.h radio_config.h si446x_api_lib.c si446x_api_lib.h si446x_cmd.h si446x_defs.h si446x_patch.h si446x_prop.h
  group common/hal
    ../../../common/hal/: hal_board.c hal_clock.c hal_energy.c hal_gpio.c hal_nvmem.c hal_uart.c
  group common/hal/inc
    ../../../common/hal/: hal.h hal_board.h hal_clock.h hal_energy.h hal_gpio.h hal_low_power.h hal_nvmem.h hal_rtc.h hal_sd.h hal_sensor.h hal_socket.h hal_uart.h
  group common/lib
    ../../../common/lib/: bootloader.c crc.c debug.c list.c portablelonglong.c printf.c serial.c sqqueue.c srandom.c
  group common/lib/inc
    ../../../common/lib/: bootloader.h crc.h data_type_def.h debug.h lib.h list.h portablelonglong.h printf.h serial.h sqqueue.h srandom.h
  group paltform
    ../../../platform/: platform.h
  group paltform/cor430/driver
    ../../../platform/core430/driver/: board.c clock.c energy.c flash.c gpio.c pmap.c si4463_arch.c timer.c uart.c
  group paltform/cor430/driver/inc
    ../../../platform/core430/driver/: board.h clock.h driver.h energy.h flash.h gpio.h pmap.h rtimer_arch.h si4463_arch.h timer.h uart.h
  group paltform/cor430/init
    ../../../platform/core430/init/: cstartup.s43 main.c
  group paltform/its_rp/driver
    ../../../platform/its_rp/driver/: ad5252.c board.c clock.c energy.c flash.c gpio.c max823r.c rtc.c rtc_asm.s43 si4432_arch.c timer.c uart.c
  group paltform/its_rp/driver/inc
    ../../../platform/its_rp/driver/: ad5252.h board.h clock.h driver.h energy.h flash.h gpio.h max823r.h rtc.h rtimer_arch.h si4432_arch.h timer.h uart.h
  group paltform/its_rp/init
    ../../../platform/its_rp/init/: cstartup.s43 main.c
  group paltform/sen_comm/driver
    ../../../platform/sen_comm/driver/: board.c clock.c flash.c gpio.c si4432_arch.c timer.c uart.c
  group paltform/sen_comm/driver/inc
    ../../../platform/sen_comm/driver/: board.h clock.h driver.h energy.h flash.h gpio.h rtimer_arch.h si4432_arch.h timer.h uart.h
  group paltform/sen_comm/init
    ../../../platform/sen_comm/init/: cstartup.s43 main.c
  group stack
    ../../../stack/: stack.c stack.h
  group stack/custom/mac
    ../../../stack/custom/mac/: mac.c mac.h
  group stack/custom/mac/core/asyn
    ../../../stack/custom/mac/core/asyn/: asyn_ctrl.c asyn_ctrl.h asyn_define.h asyn_frame.c asyn_frame.h asyn_gateway.c asyn_gateway.h asyn_general.c asyn_general.h asyn_router.c asyn_router.h asyn_terminal.c asyn_terminal.h
  group stack/custom/mac/core/sync
    ../../../stack/custom/mac/core/sync/: sync_ctrl.c sync_ctrl.h sync_define.h sync_gateway.c sync_gateway.h sync_general.c sync_general.h sync_mac_package.c sync_mac_package.h sync_router.c sync_router.h sync_terminal.c sync_terminal.h
  group stack/custom/mac/general
    ../../../stack/custom/mac/general/: assos_table.c assos_table.h general.c general.h mac_frame.c mac_frame.h mac_package.c mac_package.h neighbors.c neighbors.h
  group stack/custom/nwk
    ../../../stack/custom/nwk/: nwk_frames.c nwk_frames.h nwk_handles.c nwk_handles.h nwk_interface.h nwk_route.c nwk_route.h
  group stack/custom/phy
    ../../../stack/custom/phy/: phy_cca.c phy_cca.h phy_packet.c phy_packet.h phy_state.c phy_state.h
  group stack/module
    ../../../stack/module/mac_module/: hal_timer.c hal_timer.h m_slot.c m_slot.h m_sync.c m_sync.h m_tran.c m_tran.h mac_module.h
  group stack/stack_lib
    ../../../stack/common/: pbuf.c pbuf.h prim.h sbuf.c sbuf.h
  group sys_arch
    ../../../sys_arch/: osel_arch.c osel_arch.h
  group sys_arch/ports
    ../../../sys_arch/ports/msp430/: wsnos_port.c wsnos_port.h
  group sys_arch/wsnos
    ../../../sys_arch/wsnos/: wsnos_equeue.c wsnos_etimer.c wsnos_init.c wsnos_mem.c wsnos_pthread.c wsnos_sched.c wsnos_task.c
  group sys_arch/wsnos/inc
    ../../../sys_arch/wsnos/: wsnos.h wsnos_default.h wsnos_equeue.h wsnos_etimer.h wsnos_mem.h wsnos_pthread.h wsnos_sched.h wsnos_task.h
