<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\collector\collector.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gateway\gateway.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\router\router.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\tag\tag.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\tag_coap\tag_coap.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\tag_coap\tag_coap_cor430.ewp</path>
  </project>
  <batchBuild/>
</workspace>


