# IAR project Backup of box.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430F5359 MSP430F5359
  General.GStackSize2: 3000
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: PF_CORE_430; SILABS_RADIO_SI446X
  ICC430.newCCIncludePaths: ..\apps\cfg\; ..\bh1750\; ..\elec_clock\; //..\gprs\include\; ..\gprs_sim928a_m26\include\; ..\bluetooth\include\; ..\gznet\code\src\; ..\apps\application\control_module\include\; ..\apps\application\collect_module\acc_algo\include\; ..\apps\application\collect_module\gps\include\; ..\apps\application\collect_module\gps\nmealib\include\nmea\; ..\apps\application\collect_module\other\include\; ..\apps\application\collect_module\rfid\include\; ..\local_drive\dev\bh1750\; ..\local_drive\dev\elec_clock\; ..\local_drive\dev\m24lr64e\; ..\local_drive\dev\sensor_accelerated\; ..\local_drive\dev\sensor_humiture\; ..\local_drive\hal\inc\
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: USE_LARGE_CODE_MODEL
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F5359.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group apps/collect_module/acc_algo/include
    ../apps/application/collect_module/acc_algo/include/: acc_sensor_algo.h acc_sensor_queue.h
  group apps/collect_module/acc_algo/src
    ../apps/application/collect_module/acc_algo/src/: acc_sensor_algo.c acc_sensor_queue.c
  group apps/collect_module/gps/include
    ../apps/application/collect_module/gps/include/: gps.h
  group apps/collect_module/gps/nmealib/include
    ../apps/application/collect_module/gps/nmealib/include/nmea/: config.h context.h generate.h generator.h gmath.h info.h nmea.h parse.h parser.h sentence.h time.h tok.h units.h
  group apps/collect_module/gps/nmealib/src
    ../apps/application/collect_module/gps/nmealib/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
  group apps/collect_module/gps/src
    ../apps/application/collect_module/gps/src/: gps.c
  group apps/collect_module/other/include
    ../apps/application/collect_module/other/include/: app_acc_sensor.h app_gps.h app_heartbeat.h app_humiture.h app_light_sensor.h
  group apps/collect_module/other/src
    ../apps/application/collect_module/other/src/: app_acc_sensor.c app_gps.c app_heartbeat.c app_humiture.c app_light_sensor.c
  group apps/collect_module/rfid/include
    ../apps/application/collect_module/rfid/include/: app_rfid.h md5.h
  group apps/collect_module/rfid/src
    ../apps/application/collect_module/rfid/src/: app_rfid.c md5.c
  group apps/control_module/include
    ../apps/application/control_module/include/: app_frame.h app_led.h app_send.h app_send_list.h app_task.h ssn.h
  group apps/control_module/src
    ../apps/application/control_module/src/: app_frame.c app_led.c app_send.c app_send_list.c app_task.c ssn.c
  group bluetooth/include
    ../bluetooth/include/: blu_tx.h
  group bluetooth/src
    ../bluetooth/src/: blu_tx.c
  group cfg
    ../apps/cfg/: node_cfg.h wsnos_config.h
  group gprs/include
    ../gprs/include/: gprs_rx.h gprs_str.h gprs_tx.h
  group gprs/src
    ../gprs/src/: gprs_rx.c gprs_str.c gprs_tx.c
  group gprs_sim928a_m26/include
    ../gprs_sim928a_m26/include/: gprs_rx.h gprs_str.h gprs_tx.h
  group gprs_sim928a_m26/src
    ../gprs_sim928a_m26/src/: gprs_rx.c gprs_str.c gprs_tx.c
  group gznet
    ../gznet/code/src/: gznet.h
  group gznet/common/coap
    ../gznet/code/src/common/coap/: coap_client.c coap_client.h
  group gznet/common/dev
    ../gznet/code/src/common/dev/: dev.h radio_defs.h
  group gznet/common/dev/si4463
    ../gznet/code/src/common/dev/si4463/: radio.c radio_comm.c si446x_api_lib.c
  group gznet/common/dev/si4463/inc
    ../gznet/code/src/common/dev/si4463/: compiler_defs.h radio.h radio_comm.h radio_config.h si446x_api_lib.h si446x_cmd.h si446x_defs.h si446x_patch.h si446x_prop.h
  group gznet/common/hal
    ../gznet/code/src/common/hal/: hal_board.c hal_board.h hal_clock.c hal_clock.h hal_energy.c hal_energy.h hal_gpio.c hal_gpio.h hal_nvmem.c hal_nvmem.h hal_rtc.c hal_rtc.h hal_sensor.c hal_sensor.h hal_uart.c hal_uart.h
  group gznet/common/lib
    ../gznet/code/src/common/lib/: bootloader.c crc.c debug.c list.c portablelonglong.c printf.c serial.c sqqueue.c srandom.c
  group gznet/platform/core_430/drivers
    ../gznet/code/src/platform/core430/driver/: board.c clock.c energy.c flash.c gpio.c pmap.c rtc.c rtc_asm.s43 si4463_arch.c timer.c uart.c
  group gznet/platform/core_430/inc
    ../gznet/code/src/platform/core430/include/driver/: board.h clock.h driver.h energy.h flash.h gpio.h pmap.h rtc.h rtimer_arch.h sensor.h si4463_arch.h socket.h timer.h uart.h
  group gznet/stack
    ../gznet/code/src/stack/: stack.c stack.h
  group gznet/stack/common
    ../gznet/code/src/stack/common/: pbuf.c pbuf.h prim.h sbuf.c sbuf.h
  group gznet/stack/custom/mac
    ../gznet/code/src/stack/custom/mac/: mac.c mac.h
  group gznet/stack/custom/mac/core/asyn
    ../gznet/code/src/stack/custom/mac/core/asyn/: asyn_ctrl.c asyn_ctrl.h asyn_define.h asyn_frame.c asyn_frame.h asyn_gateway.c asyn_gateway.h asyn_general.c asyn_general.h asyn_router.c asyn_router.h asyn_terminal.c asyn_terminal.h
  group gznet/stack/custom/mac/core/sync
    ../gznet/code/src/stack/custom/mac/core/sync/: sync_ctrl.c sync_ctrl.h sync_define.h sync_gateway.c sync_gateway.h sync_general.c sync_general.h sync_mac_package.c sync_mac_package.h sync_router.c sync_router.h sync_terminal.c sync_terminal.h
  group gznet/stack/custom/mac/general
    ../gznet/code/src/stack/custom/mac/general/: assos_table.c assos_table.h general.c general.h mac_frame.c mac_frame.h mac_package.c mac_package.h neighbors.c neighbors.h
  group gznet/stack/custom/nwk
    ../gznet/code/src/stack/custom/nwk/: collector_nwk.c nwk_frames.c nwk_frames.h nwk_handles.c nwk_handles.h nwk_interface.h nwk_route.c nwk_route.h
  group gznet/stack/custom/phy
    ../gznet/code/src/stack/custom/phy/: phy_cca.c phy_cca.h phy_packet.c phy_packet.h phy_state.c phy_state.h
  group gznet/stack/module
    ../gznet/code/src/stack/module/mac_module/: hal_timer.c hal_timer.h m_slot.c m_slot.h m_sync.c m_sync.h m_tran.c m_tran.h mac_module.h
  group gznet/sys_arch
    ../gznet/code/src/sys_arch/: osel_arch.c
  group gznet/sys_arch/ports/inc
    ../gznet/code/src/sys_arch/ports/msp430/: wsnos_port.h
  group gznet/sys_arch/ports/src
    ../gznet/code/src/sys_arch/ports/msp430/: wsnos_port.c
  group gznet/sys_arch/wsnos/inc
    ../gznet/code/src/sys_arch/wsnos/: wsnos.h wsnos_default.h wsnos_equeue.h wsnos_etimer.h wsnos_mem.h wsnos_pthread.h wsnos_sched.h wsnos_task.h
  group gznet/sys_arch/wsnos/src
    ../gznet/code/src/sys_arch/wsnos/: wsnos_equeue.c wsnos_etimer.c wsnos_init.c wsnos_mem.c wsnos_pthread.c wsnos_sched.c wsnos_task.c
  group local_drive/dev/bh1750
    ../local_drive/dev/bh1750/: bh1750.c bh1750.h
  group local_drive/dev/elec_clock
    ../local_drive/dev/elec_clock/: elec_lock.c elec_lock.h
  group local_drive/dev/m24lr64e
    ../local_drive/dev/m24lr64e/: rfid.c rfid.h
  group local_drive/dev/sensor_accelerated
    ../local_drive/dev/sensor_accelerated/: sensor_accelerated.c sensor_accelerated.h
  group local_drive/dev/sensor_humiture
    ../local_drive/dev/sensor_humiture/: sensor_humiture.c sensor_humiture.h
  group local_drive/hal/inc
    ../local_drive/hal/inc/: hal_acc_sensor.h hal_bh1750.h hal_elec_lock.h hal_rfid.h
  group local_drive/hal/src
    ../local_drive/hal/src/: hal_acc_sensor.c hal_bh1750.c hal_elec_lock.c hal_rfid.c
  group start
    ../apps/start/: cstartup.s43 main.c
